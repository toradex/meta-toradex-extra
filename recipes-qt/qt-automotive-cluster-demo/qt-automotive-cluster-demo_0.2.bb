include qt-automotive-cluster-demo.inc

SRC_URI_append = "git://github.com/toradex/QtAutomotiveClusterDemo.git;branch=master"

SRCREV = "93ccd9d2aefa844035ca3976f5e8dceed007f80a"
