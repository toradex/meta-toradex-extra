RDEPENDS_${PN} += " \
        libmcc \
        libmcc-dev \
        libmcc-staticdev \
        kernel-module-mcc \
        kernel-module-mcc-dev \
"
